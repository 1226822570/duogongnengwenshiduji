# Keil uVision project Project.uvprojx, settings and files
target GD32E23x (6140000::V6.14::ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230
  c include: .\GD32E23x_standard_peripheral\Include;.\CMSIS\GD\GD32E23x\Include;.\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ../: main.c gd32e23x_it.c systick.c
    ./src/: uart.c mcu_api.c protocol.c system.c rc5_decode.c rc5_encode.c oc.c SHT30.c myiic.c oled.c irsend.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32E23x/Source/: system_gd32e23x.c
  group Peripherals
    ../../Firmware/GD32E23x_standard_peripheral/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32E23x/Source/ARM/: startup_gd32e23x.s
  group Doc
    ../: readme.txt
  group inc
    ./inc/: main.h mcu_api.h protocol.h system.h systick.h wifi.h gd32e23x_libopt.h ir_decode.h rc5_decode.h rc5_encode.h SHT30.h myiic.h oled.h oledfont.h
software components: CMSIS:CORE 5.0.2
